# Keil uVision project BootLoader.uvprojx, settings and files
target BootLoader (6190000::V6.19::ARMCLANG)
  device: STM32G431CBUx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.5.0
  cpu: IRAM(0x20000000,0x00008000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: BootLoader +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=3
  c define: USE_HAL_DRIVER,USE_FULL_LL_DRIVER
  c include: .;.\Configs;.\CubeMX\Core\Inc;.\CubeMX\Drivers\CMSIS\Core\Include;.\CubeMX\Drivers\STM32G4xx_HAL_Driver\Inc;.\CubeMX\Drivers\CMSIS\Device\ST\STM32G4xx\Include;.\Components\FreeRTOS\include;.\Components\TinyUSB;.\Components\Graphics
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group HALDriver
    ./CubeMX/Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal.c stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_hal_comp.c stm32g4xx_hal_cordic.c stm32g4xx_hal_cortex.c stm32g4xx_hal_crc.c stm32g4xx_hal_crc_ex.c stm32g4xx_hal_cryp.c stm32g4xx_hal_cryp_ex.c stm32g4xx_hal_dac.c stm32g4xx_hal_dac_ex.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_exti.c stm32g4xx_hal_fdcan.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_fmac.c stm32g4xx_hal_gpio.c stm32g4xx_hal_hrtim.c stm32g4xx_hal_i2c.c stm32g4xx_hal_i2c_ex.c stm32g4xx_hal_i2s.c stm32g4xx_hal_irda.c stm32g4xx_hal_iwdg.c stm32g4xx_hal_lptim.c stm32g4xx_hal_nand.c stm32g4xx_hal_nor.c stm32g4xx_hal_opamp.c stm32g4xx_hal_opamp_ex.c stm32g4xx_hal_pcd.c stm32g4xx_hal_pcd_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_qspi.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_rng.c stm32g4xx_hal_rtc.c stm32g4xx_hal_rtc_ex.c stm32g4xx_hal_sai.c stm32g4xx_hal_sai_ex.c stm32g4xx_hal_smartcard.c stm32g4xx_hal_smartcard_ex.c stm32g4xx_hal_smbus.c stm32g4xx_hal_smbus_ex.c stm32g4xx_hal_spi.c stm32g4xx_hal_spi_ex.c stm32g4xx_hal_sram.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c stm32g4xx_hal_usart.c stm32g4xx_hal_usart_ex.c stm32g4xx_hal_wwdg.c stm32g4xx_ll_adc.c stm32g4xx_ll_comp.c stm32g4xx_ll_cordic.c stm32g4xx_ll_crc.c stm32g4xx_ll_crs.c stm32g4xx_ll_dac.c stm32g4xx_ll_dma.c stm32g4xx_ll_exti.c stm32g4xx_ll_fmac.c stm32g4xx_ll_fmc.c stm32g4xx_ll_gpio.c stm32g4xx_ll_hrtim.c stm32g4xx_ll_i2c.c stm32g4xx_ll_lptim.c stm32g4xx_ll_lpuart.c stm32g4xx_ll_opamp.c stm32g4xx_ll_pwr.c stm32g4xx_ll_rcc.c stm32g4xx_ll_rng.c stm32g4xx_ll_rtc.c stm32g4xx_ll_spi.c stm32g4xx_ll_tim.c stm32g4xx_ll_ucpd.c stm32g4xx_ll_usart.c stm32g4xx_ll_usb.c stm32g4xx_ll_utils.c
  group CubeMX/Core
    ./CubeMX/Core/Src/: dma.c gpio.c rtc.c spi.c stm32g4xx_hal_msp.c stm32g4xx_it.c system_stm32g4xx.c tim.c usart.c usb.c stm32g4xx_hal_timebase_tim.c
  group BSP
    ./BSP/: BSP.cpp MXGeneratedInit.cpp SPI.cpp Timer.cpp TimerChannel.cpp
  group User
    ./User/: ErrorHandler.cpp main.cpp FreeRTOSInnerTaskMemorys.c startup_stm32g431xx.s
  group Onboards
    ./Onboards/: Beep.cpp Button.cpp NorFlash.cpp Onboards.cpp ST7735.cpp WS2812.cpp
  group Util
    ./Util/: BootLoader.cpp CallbackFunction.cpp UTF8Praser.cpp
  group Util/Color
    ./Util/Color/: Color.cpp RGB565.cpp
  group Util/MutliThread
    ./Util/MutliThread/: MutexLock.cpp
  group Components/FreeRTOS
    ./Components/FreeRTOS/: croutine.c event_groups.c list.c port.c queue.c stream_buffer.c tasks.c timers.c
    ./Components/FreeRTOS/portable/MemMang/: heap_3.c
  group Components/Graphics
    ./Components/Graphics/Basic/: Bitmap.cpp Focusable.cpp GraphicsFunction.cpp GraphicsObject.cpp Offset.cpp Size.cpp
    ./Components/Graphics/Font/: Font.cpp
    ./Components/Graphics/Text/: Text.cpp
  group Resource
    ./Resource/: LocalResource.cpp Resource.cpp
  group Resource/Fonts
    ./Resource/Fonts/: MisterPixel.cpp
